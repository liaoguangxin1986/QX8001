# Keil uVision project test_app.uvproj, settings and files
target test_app (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.1.1
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: test_app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ../output/test_app.bin ../output/test_app.axf
  c flags: Optim=1 wLevel=2
  c include: ..\user;..\startup;..\driver
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20008000 size 0x14000
  scatter file: ..\output\test_app.sct
  group startup
    ../startup/: system_iris.c startup_hs100.s
  group driver
    ../driver/: uart_driver.c ar0237_driver.c sys.c gpio_driver.c i2c0_driver.c spi0_driver.c pll_driver.c i2c1_driver.c mipi_csi0_driver.c ov2281_driver.c
  group user
    ../user/: main.c hs_dsp.c protocol.c
